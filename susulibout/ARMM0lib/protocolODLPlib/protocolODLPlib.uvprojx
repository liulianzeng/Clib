# Keil uVision project protocolODLPlib.uvprojx, settings and files
target protocolODLPlib (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ..\..\..\MDKlib\MDKsusuprotocolODLPlib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\protocolODLPlib;..\..\..\lianbiaoquqelib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group lib
    ../../../protocolODLPlib/: susuprotocolODLPlib.c
